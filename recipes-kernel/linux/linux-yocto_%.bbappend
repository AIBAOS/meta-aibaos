LINUX_VERSION_EXTENSION = "-ibao"